# IAR project CECS_ISOInputModule.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __HSE__; EMB_FLASH; NDEBUG; _FLASH_PROG
  ICCARM.CCIncludePath2: ; config\include\; library\include\; Evkit\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CECS_ISOInputModule.srec
  ILINK.IlinkOutputFile: CECS_ISOInputModule.out
  ILINK.IlinkIcfFile: C:\Project2015\CECS_Proj\EWIAR_Source\CECS_ISOInputModule\config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: CECS_ISOInputModule.c def_application.h
  group config
    config/: cortexm3_macro.s stm32f10x_it.c stm32f10x_vector.c
  group config/include
    config/include/: arm_comm.h stm32f10x_conf.h stm32f10x_it.h
  group evkit
    EVKIT/: evkit_adc.c evkit_can.c evkit_counter3_4.c evkit_io.c evkit_message.c evkit_uart1.c evkit_uart3.c
  group evkit/include
    EVKIT/include/: evkit_adc.h evkit_can.h evkit_counter3_4.h evkit_io.h evkit_message.h evkit_uart1.h evkit_uart3.h
  group library
    library/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group library/include
    library/include/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
